# Keil uVision project BLDC_G431_Validation.uvprojx, settings and files
target BLDC_control V1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BLDC_control V1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../../platform;../validation;../../../motor;../../../control;../platform;../runtime;../communication;../../../control/commissioning;../validation/runner;../validation/control;../validation/bringup;../validation/timing;../validation/communication
  asm include: ../platform;../runtime;../communication;../../../control/commissioning;../validation/runner;../validation/control;../validation/bringup;../validation/timing;../validation/communication
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c comp.c cordic.c dac.c fdcan.c opamp.c spi.c tim.c usart.c usb.c stm32g4xx_it.c stm32g4xx_hal_msp.c dma.c
  group Application/User/Platform
    ../platform/: control_time_source.c realtime_motor_io.c position_observation.c bus_observation.c hardware_trip.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cordic.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Validation/Entry & Bringup
    ../validation/runner/: target_validation.c
    ../validation/control/: current_hold.c
    ../validation/bringup/: protection_probe.c
    ../validation/timing/: timing_probe.c
    ../../../control/commissioning/: voltage_open_loop.c
  group Validation/Observe Support
    ../validation/runner/: target_observe_runtime.c
    ../validation/timing/: current_capture.c compute_probe.c compute_comparison.c controller_profile.c irq_timing.c stage_budget.c stage_budget_runtime.c
    ../platform/: cordic_math.c
  group Shared/Motor
    ../../../motor/: motor.c control_runtime.c
    ../../../control/commissioning/: rotor_alignment.c
  group Shared/Control
    ../../../control/: position_estimator.c current_measurement.c foc_math.c current_controller.c electrical_angle.c speed_controller.c
  group Validation/Communication
    ../validation/communication/: vofa.c motor_vofa.c
  group Validation/Timing
    ../validation/timing/: timing_entry.c runtime_timing.c runtime_timing_runtime.c
    ../platform/: cordic_math.c
target BLDC_G431_Observe (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: as above
  output: BLDC_G431_Observe +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,BLDC_G431_RUNTIME_ENTRY,BLDC_G431_DIAGNOSTICS,BLDC_G431_OBSERVE_ENTRY
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../../platform;../runtime;../../../motor;../communication;../../../control;../platform;../../../control/commissioning;../validation/runner;../validation/control;../validation/bringup;../validation/timing;../validation/communication
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group added to the first target's files
    ../validation/communication/: target_uart.c target_vofa.c
  group left out of the first target's files
    ../../../control/commissioning/: voltage_open_loop.c
target BLDC_G431_Timing (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: as above
  output: BLDC_G431_Timing +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,BLDC_G431_TIMING_ENTRY
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group left out of the first target's files
    ../../../control/commissioning/: voltage_open_loop.c
software components: CMSIS:CORE 4.3.0
